Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Номер проекта
Time: 2022-09-05T10:50:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190225_1515(x64) - Exporter 19.2.10.7 - Альтернативный интерфейс 19.2.10.7
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 05 10:50:45 2022 * Host: Dell * Database: C:\Users\6EDA~1\AppData\Local\Temp\{ED6D998F-CC0F-45AB-A6AC-DAC1978B0F9E}\ifc * Database version: 5507 * Database creation date: Mon Sep 05 10:50:41 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 05 10:50:41 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 05 10:50:41 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: П

# IfcSite, Default
RefLatitude: 55, 44, 57, 789001; RefLongitude: 37, 38, 4, 304809; RefElevation: 0 mm

# IfcBuilding, Наименование здания
LongName: Наименование здания
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
In: Наименование здания
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 1 модуль (2)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 1 модуль
Name
КНС_Выключатели_DKC:1 модуль:532961
КНС_Переключатели_DKC:1 модуль:541158

# IfcBuildingElementProxy: 1 модуль (29)
In: Этаж 01
Type - Material: DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: 1 модуль
Name (КНС_СуппортДляМонтажаЭУИСерииVivaНаDIN-рейкуИлиМонтажнуюПлату_DKC:1 модуль:...)
562448
565724
570738
590201
590215
590219
590223
590227
590231
590235
590239
590283
590285
590287
590323
590325
593648
593662
593666
593670
593674
593682
593686
599049
599067
599071
599075
601829
612093

# IfcBuildingElementProxy: 2 модуля (2)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2 модуля
Name
КНС_Выключатели_DKC:2 модуля:585040
КНС_Переключатели_DKC:2 модуля:596405

# IfcBuildingElementProxy: 2 модуля (2)
In: Этаж 01
Type - Material: DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: 2 модуля
Name
КНС_СуппортДляМонтажаЭУИСерииVivaНаDIN-рейкуИлиМонтажнуюПлату_DKC:2 модуля:546967
КНС_Выключатели_DKC:2 модуля:616555

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:HDMI:593661
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:HDMI:538659
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:HDMI:593647
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: Keystone, КНС_АдаптерыДляИнформационныхРазъемов_DKC:Keystone:530347
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Keystone

# IfcBuildingElementProxy: Keystone, КНС_АдаптерыДляИнформационныхРазъемов_DKC:Keystone:582287
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Keystone

# IfcBuildingElementProxy: Keystone, КНС_АдаптерыДляИнформационныхРазъемов_DKC:Keystone:582270
In: Этаж 01
Type - Material: DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Keystone

# IfcBuildingElementProxy: REICHLE-DE-MASSARI, КНС_АдаптерыДляИнформационныхРазъемов_DKC:REICHLE-DE-MASSARI:582290
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: REICHLE-DE-MASSARI

# IfcBuildingElementProxy: RJ-11, КНС_РозеткиТелефонные_DKC:RJ-11:543627
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: RJ-11

# IfcBuildingElementProxy: RJ-11, КНС_РозеткиТелефонные_DKC:RJ-11:599048
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: RJ-11

# IfcBuildingElementProxy: RJ-12, КНС_РозеткиТелефонные_DKC:RJ-12:599066
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: RJ-12

# IfcBuildingElementProxy: RJ-12, КНС_РозеткиТелефонные_DKC:RJ-12:599074
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: RJ-12

# IfcBuildingElementProxy: RJ-12, КНС_РозеткиТелефонные_DKC:RJ-12:599070
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: RJ-12

# IfcBuildingElementProxy: Siemon, КНС_АдаптерыДляИнформационныхРазъемов_DKC:Siemon:582299
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Siemon

# IfcBuildingElementProxy: Systimax, КНС_АдаптерыДляИнформационныхРазъемов_DKC:Systimax:582314
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Systimax

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:USB 2.0:593673
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:USB 2.0:593665
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:USB 2.0:593669
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:USB 3.0:593685
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:USB 3.0:593677
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSBс1разъемом1модуль_DKC:USB 3.0:593681
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: Белый (2)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белый
Name
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторками_DKC:Белый:546149
КНС_ЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторкамиМоноблок_DKC:Белый:548858

# IfcBuildingElementProxy: Заглушки, КНС_Заглушки_DKC:Заглушки:508023
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Заглушки

# IfcBuildingElementProxy: Заглушки, КНС_Заглушки_DKC:Заглушки:587627
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Заглушки

# IfcBuildingElementProxy: Заглушки, КНС_Заглушки_DKC:Заглушки:587619
In: Этаж 01
Type - Material: DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Заглушки

# IfcBuildingElementProxy: Категория 5e, КНС_КомпьютерныеРозетки_DKC:Категория 5e:590214
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Категория 5e

# IfcBuildingElementProxy: Категория 5e (2)
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Категория 5e
Name (КНС_КомпьютерныеРозетки_DKC:Категория 5e:...)
590200
590324

# IfcBuildingElementProxy: Категория 5e (2)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Категория 5e
Name (КНС_КомпьютерныеРозетки_DKC:Категория 5e:...)
535404
590322

# IfcBuildingElementProxy: Категория 6, КНС_КомпьютерныеРозетки_DKC:Категория 6:590226
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Категория 6

# IfcBuildingElementProxy: Категория 6, КНС_КомпьютерныеРозетки_DKC:Категория 6:590222
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Категория 6

# IfcBuildingElementProxy: Категория 6, КНС_КомпьютерныеРозетки_DKC:Категория 6:590218
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Категория 6

# IfcBuildingElementProxy: Категория 6 экранированная, КНС_КомпьютерныеРозетки_DKC:Категория 6 экранированная:590238
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Категория 6 экранированная

# IfcBuildingElementProxy: Категория 6 экранированная, КНС_КомпьютерныеРозетки_DKC:Категория 6 экранированная:590234
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Категория 6 экранированная

# IfcBuildingElementProxy: Категория 6 экранированная, КНС_КомпьютерныеРозетки_DKC:Категория 6 экранированная:590230
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Категория 6 экранированная

# IfcBuildingElementProxy: Категория 6А, КНС_КомпьютерныеРозетки_DKC:Категория 6А:590286
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Категория 6А

# IfcBuildingElementProxy: Категория 6А, КНС_КомпьютерныеРозетки_DKC:Категория 6А:590284
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Категория 6А

# IfcBuildingElementProxy: Категория 6А, КНС_КомпьютерныеРозетки_DKC:Категория 6А:590282
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Категория 6А

# IfcBuildingElementProxy: Красный (2)
In: Этаж 01
Type - Material: DKC_Пластик_Красный
Pset_BuildingElementProxyCommon - Reference: Красный
Name
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторками_DKC:Красный:600838
КНС_ЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторкамиМоноблок_DKC:Красный:603726

# IfcBuildingElementProxy: Лого, Лого:Лого:526129
In: Этаж 01
Type - Material: DKC_КрасныйЛого
Pset_BuildingElementProxyCommon - Reference: Лого

# IfcBuildingElementProxy: Серый (2)
In: Этаж 01
Type - Material: DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: Серый
Name
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторками_DKC:Серый:600822
КНС_ЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторкамиМоноблок_DKC:Серый:603710

# IfcBuildingElementProxy: Текст модели:100 мм Arial (45)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 100 мм Arial

# IfcBuildingElementProxy: Текст модели:150 мм Arial (10)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 150 мм Arial

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial

# IfcBuildingElementProxy: Черный (2)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Черный
Name
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторками_DKC:Черный:600835
КНС_ЭлектрическиеРозеткиШтекерныеСЗаземлениемИСоШторкамиМоноблок_DKC:Черный:603723
